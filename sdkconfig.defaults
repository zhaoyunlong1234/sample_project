## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="Pura70"
CONFIG_EXAMPLE_WIFI_PASSWORD="zhaoyunlong"
CONFIG_BLINK_GPIO=48
CONFIG_BLINK_PERIOD=1000
```
